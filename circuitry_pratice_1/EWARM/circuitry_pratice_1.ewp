# IAR project circuitry_pratice_1.ewp, settings and files
configuration circuitry_pratice_1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053C8 ST STM32L053C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: circuitry_pratice_1.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32L0xx_HAL_Driver
    ./: 
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_pwr.c stm32l0xx_hal_flash.c stm32l0xx_hal_uart.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr_ex.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32l0xx.c
  group Application
    ./: 
  group Application/EWARM
    ./:  startup_stm32l053xx.s
  group Application/User
    ./: 
    ../Src/: stm32l0xx_it.c main.c gpio.c usart.c stm32l0xx_hal_msp.c
